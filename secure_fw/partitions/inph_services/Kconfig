## secure_fw/partitions/inph_services/Kconfig
```kconfig
menuconfig TFM_PARTITION_INPH_SERVICES
    bool "Enable the INPH_SERVICES Partition"
    default n
```
